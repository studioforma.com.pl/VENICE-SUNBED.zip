Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Sunbed - v4.ifc
Time: 2023-11-10T15:30:54
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (13)
Name
 | 1_6 - ObjectType: SketchupGroup
 | 1_5 - ObjectType: SketchupGroup
 | 1_4 - ObjectType: SketchupGroup
 | 1_3 - ObjectType: SketchupGroup
 | 1_2 - ObjectType: SketchupGroup
 | 1_1 - ObjectType: SketchupGroup
 | 1_0 - ObjectType: SketchupGroup
 | 1_7 - ObjectType: SketchupGroup
 | 1_8 - ObjectType: SketchupGroup
 | 1_9 - ObjectType: SketchupGroup
 | 1_10 - ObjectType: SketchupGroup
 | 1_11 - ObjectType: SketchupGroup
 | 1_12 - ObjectType: SketchupGroup
